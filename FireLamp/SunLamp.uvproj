# Keil uVision project SunLamp.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: FireLamp +hex
  c flags: Optimize=8
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c STC8G_H_ADC.c STC8G_H_Delay.c STC8G_H_GPIO.c STC8G_H_UART.c STC8G_H_UART_Isr.c STC8G_H_NVIC.c STC8G_H_Timer.c STC8H_PWM.c STC8G_H_Exti.c
