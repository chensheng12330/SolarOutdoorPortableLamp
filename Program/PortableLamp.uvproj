# Keil uVision project PortableLamp.uvproj, settings and files
target Target 1 (MCS-51)
  device: AI8051U-8Bit Series AI
  cpu: IRAM(0-0xFF) XRAM(0-0x7FFF) IROM(0-0xFFFF) CLOCK(35000000)
  output: SolarOutdoorPortableLamp
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c STC8G_H_ADC.c STC8G_H_Delay.c STC8G_H_GPIO.c STC8G_H_UART.c STC8G_H_UART_Isr.c STC8G_H_NVIC.c STC8G_H_Timer.c STC8H_PWM.c STC8G_H_Exti.c
