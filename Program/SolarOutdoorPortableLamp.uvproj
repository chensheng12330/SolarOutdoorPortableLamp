# Keil uVision project SolarOutdoorPortableLamp.uvproj, settings and files
target SolarPortableLamp (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: SolarOutdoorPortableLamp +hex
  group Source
    ./: main.c 功能说明.txt STC8G_H_ADC.c STC8G_H_Delay.c STC8G_H_Exti.c STC8G_H_GPIO.c STC8G_H_NVIC.c STC8G_H_Timer.c STC8G_H_Timer_Isr.c STC8G_H_UART.c STC8G_H_UART_Isr.c STC8H_PWM.c WS2812B-UART1-SPI-DMA.c
